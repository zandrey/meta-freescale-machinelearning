# Add PIC flag into compilation
CFLAGS += "-fPIC"
CXXFLAGS += "-fPIC"
